options:
  parameters:
    generate_options: qt_gui
    id: emitter_receiver
    output_language: python
    title: emitter_receiver
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    start: 1.5e9
    step: 100e6
    stop: 3e9
    value: 2.4e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: Chirp
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport time\n\nfrom gnuradio import gr\n\n\"\"\" Inputs:\n   frequencia central\n   variação de frequencia\n   duração da variação\n\"\"\"\n\nclass Chirp(gr.sync_block):\n    def __init__(self, sample_rate=44100.0, frequency=100, frequency_range=20, duration=0.5):\n        gr.sync_block.__init__(\n            self,\n            name=\"Chirp\",\n            in_sig=None,\n            out_sig=[np.complex64]\n            # out_sig=[np.float32]\n        )\n        # Own Parans\n        self.sample_rate = sample_rate\n        self.duration = duration\n        self.frequency = frequency\n        self.frequency_range = frequency_range\n        \n        # Control Params\n        self.time = 0.0\n        self.phase = 0.0\n        self.last_reset_time = 0\n        self.t0 = 0.0\n\n    def work(self, input_items, output_items):\n        # This is typically a buffer of fixed size that the signal generator fills with output samples\n        output = output_items[0]\n        print(len(output))\n        #print(\"New Cycle\")\n        #print(self.t0)\n     \n        # Loop that itereates over output buffer\n        for i in range(len(output)):\n            # current time of the signal generator\n            # sample_rate is the sample rate at which the signal is being generated\n            # t is the time at which the current sample being generated will be played\n            t = self.time + i / self.sample_rate\n            current_freq = (self.frequency-self.frequency_range/2) + (t-self.t0) / self.duration * self.frequency_range\n            # the current phase of the sine wave. We're adding the phase increment\n            #self.phase += 2 * np.pi * current_freq / self.sample_rate\n            \n            self.phase = np.exp(2j*np.pi*(-self.frequency_range/2*(t-self.t0)+self.frequency_range/(2*self.duration)*np.power(t-self.t0,2)))\n            # the current sample of the signal wave is calculated by taking the sine of the current phase\n            output[i] = self.phase\n            \n            if(t-self.t0 >= self.duration):\n       \t      self.t0 = t\n            # output[i] = np.sin(self.phase)\n            #if(i%500==0):\n            #  print(self.phase)\n            #  print(output[i])\n              \n            # Kaiser  + Tuckey\n            # jitter - não pode haver\n            \n        # Updated to reflect the time at which the last sample of the output buffer will be played\n        self.time += len(output) / self.sample_rate\n        # The length of the output buffer is returned to indicate how many samples were generated.\n        return len(output)\n        \n        \"\"\"  output = output_items[0]\n        self.frequency = self.frequency - self.frequency_range/2\n        for i in range(len(output)):\n            t = self.time + i / self.sample_rate\n            freq = self.frequency + t / self.duration * self.frequency_range\n            self.phase += 2 * np.pi * freq / self.sample_rate\n            output[i] = np.sin(self.phase)\n        self.time += len(output) / self.sample_rate\n        return len(output)\n        \"\"\"    \n\n"
    duration: '2'
    frequency: '0'
    frequency_range: 1e3
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ficheiros_dinamicos/samples_fifo
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ficheiros_dinamicos/chirp_data.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: 10e3
    fc: center_frequency
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Emissor frequencia"'
    type: complex
    update_time: '0.0005'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: 1e3
    fc: center_frequency
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Recetor frequencia"'
    type: complex
    update_time: '0.0005'
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"chirp in time domain"'
    size: '1024'
    srate: samp_rate
    type: complex
    yunit: '"miliseconds"'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"chirp in time domain"'
    size: '1024'
    srate: samp_rate
    type: complex
    yunit: '"miliseconds"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 1e3
    center_freq0: center_frequency
    gain0: '20'
    gain_type0: power
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 1e3
    center_freq0: center_frequency
    gain0: '20'
    gain_type0: power
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
